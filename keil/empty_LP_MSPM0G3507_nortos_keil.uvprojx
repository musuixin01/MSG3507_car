# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSG3507_car (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: "D:\E_Lab_Base\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\tools\keil\syscfg.bat" "D:\E_Lab_Base\02_Projects\Keil\MSP3507\MSG3507_car\keil" empty.syscfg
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;../App;../BSP;../Drivers;../Drivers/communication;../Drivers/oled;../Drivers/mpu6050;..\..\..\..\..\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include;..\..\..\..\..\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\source\ti\devices\msp\m0p;..\..\..\..\..\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\source\ti\driverlib;..\..\..\..\..\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: ROM 0x20200000 size 0x8000
  memory RVCT7: ROM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\E_Lab_Base\01_Software_Installers\TI\MSPM0-SDK\mspm0_sdk_2_11_00_07\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group App
    ../App/: main.c app_controller.c app_controller.h app_config.h control_pid.c control_pid.h line_follow.c line_follow.h wheel_speed_pi.c wheel_speed_pi.h ball_control.c ball_control.h vision_protocol.c vision_protocol.h user_interface.c user_interface.h
  group BSP
    ../BSP/: bsp_motor.c bsp_motor.h bsp_servo.c bsp_servo.h bsp_encoder.c bsp_encoder.h bsp_buzzer.c bsp_buzzer.h
  group Drivers
    ../Drivers/communication/: communication.c communication.h
    ../Drivers/oled/: oled.c oled.h
    ../Drivers/mpu6050/: mpu6050.h mpu6050.c
  group SysConfig
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
  group Startup
    ./: startup_mspm0g350x_uvision.s
